# include customizations defined in core-image-minimal-common.inc
require core-image-minimal-common.inc
