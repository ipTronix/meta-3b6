FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0000-add-max-fscale-to-sysfs.patch"

